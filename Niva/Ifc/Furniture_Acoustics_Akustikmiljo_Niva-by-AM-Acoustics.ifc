Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Furniture_Acoustics_Akustikmiljo_Niva-by-AM-Acoustics.ifc
Time: 2020-01-15T09:06:05
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFurnishingElement: Nivå by AM Acoustics
ePset_BIMobjectScript - LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): Nivå by AM Acoustics; SKU (BO_prodsku): niva; ManufacturName (BO_Manufac): Akustikmiljö; ProductFamily (BO_prodfam): Furniture; ProductGroup (BO_prodgroup): Wall- and Ceiling acoustics; ManufacturCountry (BO_mancont): Sweden; DesignCountry (BO_designcont): Sweden; EditionNumber (BO_edinum): 1; Width (BO_width): 593; Height (BO_height): 593; Depth (BO_depth): 0; Weight (BO_weight): 0; QR (BO_boqrurl): http://bimobject.com/akustikmiljo/product/niva; ProductDataUrl (BO_prodaturl): bimobject.com/akustikmiljo/product/niva; ProductUrl (BO_producturl): https://www.gotessons.com/en/products/wall-and-ceiling-acoustics/niva-ecosund-sound-absorbing-ceiling-panel/; ProductCertification (BO_prodcert): https://www.gotessons.com/en/quality-and-environment/; MaterialMain (BO_mainmat): Polyester; MaterialSecondary (BO_secmat): Polyester; BimObjectMainCategory (BO_bomaincat): Furniture; BimObjectMainCategoryCode (BO_bomaincat_code): furniture; BimObjectCategory (BO_bocat): Acoustics; BimObjectCategoryCode (BO_bocat_code): furniture-acoustics; IfcClassification (BO_ifcclas): Furniture; UnspcCode (BO_unspc): 56; Uniclass2015Code (BO_uniclass2015_code): EF_40_30; Uniclass2015Description (BO_uniclass2015_desc): Furnishings; UniFormat2Code (BO_uniformat2_code): E20; UniFormat2Description (BO_uniformat2_name): FURNISHINGS; RegionEurope (BO_europe): SE
